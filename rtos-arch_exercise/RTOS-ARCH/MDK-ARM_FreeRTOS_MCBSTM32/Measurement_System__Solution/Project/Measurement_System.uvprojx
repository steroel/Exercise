# Keil uVision project Measurement_System.uvprojx, settings and files
target MCBSTM32_Flash (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Measurement_System
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: RVDS_ARMCM3_LM3S102
  c include: ..\Measurement_System\Hardware_BSP;..\Measurement_System\Application;..\Measurement_System\FreeRTOS\FreeRTOSV8.2.3\FreeRTOS\Source\include;..\Measurement_System\FreeRTOS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Measurement_System/Application/: osObjects.h osObjects.c Main_Measurement_Application.c Task_Init.c Task_Heartbeat.c Task_Measurement_Signal.c Task_Measurement_Queue.c Task_PushButton.c
  group FreeRTOS
    ../Measurement_System/FreeRTOS/: FreeRTOSConfig.h
    ../Measurement_System/FreeRTOS/FreeRTOSV8.2.3/FreeRTOS/Source/: list.c queue.c tasks.c event_groups.c timers.c
    ../Measurement_System/FreeRTOS/FreeRTOSV8.2.3/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Measurement_System/FreeRTOS/FreeRTOSV8.2.3/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Hardware_BSP
    ../Measurement_System/Hardware_BSP/: LCD_KS0066U.c MCBSTM32.c MCBSTM32_SPI_SD.c Serial.c Microcontroller_Board_Init.c
software components: CMSIS:CORE 5.3.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0

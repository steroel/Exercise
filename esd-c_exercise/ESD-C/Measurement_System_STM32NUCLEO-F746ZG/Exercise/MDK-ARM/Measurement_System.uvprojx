# Keil uVision project Measurement_System.uvprojx, settings and files
target Measurement_System (6160000::V6.16::ARMCLANG)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF)         CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Measurement_System +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ..\Measurement_System\Hardware_Device_Abstraction\AnalogMeasurement;..\Measurement_System\Hardware_Device_Abstraction\ComSerial;..\Measurement_System\Hardware_Device_Abstraction\UserIndication;..\Measurement_System\Hardware_Device_Abstraction\UserInput;..\Measurement_System\Hardware_Device_Abstraction\UserOutput;..\Measurement_System\Library\State_Machine;..\Measurement_System\Measurement_Application\Measurement_Controller;..\Measurement_System\Measurement_Application\Measurement;..\Measurement_System\System_Management;..\Measurement_System\Hardware_Device_Abstraction;..\Measurement_System\Hardware_Device_Driver;..\Measurement_System\Hardware_Device_Driver\Microcontroller_Driver;..\Measurement_System\Hardware_Device_Driver\Board_Driver;..\Measurement_System\Measurement_Application;..\Measurement_System\Hardware_Device_Driver\Microcontroller_Driver\STM32F7xx\HAL_Driver\Inc;..\Measurement_System\Hardware_Device_Driver\Board_Driver\STM32F7xx_NUCLEO_144;..\Measurement_System\Hardware_Device_Driver\Board_Driver\STM32F7xx_NUCLEO_144\Button;..\Measurement_System\Hardware_Device_Driver\Board_Driver\STM32F7xx_NUCLEO_144/LED;..\Measurement_System\Hardware_Device_Driver\Microcontroller_Configuration\STM32F7xx;..\Measurement_System\Hardware_Device_Driver\Microcontroller_Configuration\STM32F7xx\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group System_Management
    ../Measurement_System/System_Management/: Measurement_Application_main.c SystemManager.h SystemManager.c
  group Measurement_Application
    ../Measurement_System/Measurement_Application/: ApplicationManager.h ApplicationManager.c
  group Measurement_Application/Measurement_Controller
    ../Measurement_System/Measurement_Application/Measurement_Controller/: MeasurementController.c MeasurementController.h MeasurementController_Events.h
  group Measurement_Application/Measurement
    ../Measurement_System/Measurement_Application/Measurement/: Measurement.h Measurement.c VoltageMeasurement.h VoltageMeasurement.c CurrentMeasurement.h CurrentMeasurement.c ResistanceMeasurement.h ResistanceMeasurement.c
  group Hardware_Device_Abstraction
    ../Measurement_System/Hardware_Device_Abstraction/: DeviceAbstractionManager.h DeviceAbstractionManager.c
  group Hardware_Device_Abstraction/AnalogMeasurement
    ../Measurement_System/Hardware_Device_Abstraction/AnalogMeasurement/: I_AnalogMeasurement.h I_AnalogMeasurement_Config.h ICB_AnalogMeasurement.h AnalogMeasurement.h AnalogMeasurement.c
  group Hardware_Device_Abstraction/UserIndication
    ../Measurement_System/Hardware_Device_Abstraction/UserIndication/: I_UserIndication.h I_UserIndication_Config.h UserIndication.h UserIndication.c
  group Hardware_Device_Abstraction/UserInput
    ../Measurement_System/Hardware_Device_Abstraction/UserInput/: I_UserInput.h I_UserInput_Config.h UserInput.h UserInput.c
  group Hardware_Device_Driver
    ../Measurement_System/Hardware_Device_Driver/: DriverManager.h DriverManager.c
  group Hardware_Device_Driver/Board_Driver
    ../Measurement_System/Hardware_Device_Driver/Board_Driver/: I_Button.h I_Button_Config.h I_Button_Types.h I_LED.h I_LED_Config.h
  group Hardware_Device_Driver/Board_Driver/STM32F7xx_NUCLEO_144/Button
    ../Measurement_System/Hardware_Device_Driver/Board_Driver/STM32F7xx_NUCLEO_144/Button/: STM32F7xx_NUCLEO_144_Button.c STM32F7xx_NUCLEO_144_Button.h
  group Hardware_Device_Driver/Board_Driver/STM32F7xx_NUCLEO_144/LED
    ../Measurement_System/Hardware_Device_Driver/Board_Driver/STM32F7xx_NUCLEO_144/LED/: STM32F7xx_NUCLEO_144_LED.c STM32F7xx_NUCLEO_144_LED.h
  group Hardware_Device_Dirver/Board_Driver/STM32F7xx_NUCLEO_144
    ../Measurement_System/Hardware_Device_Driver/Board_Driver/STM32F7xx_NUCLEO_144/: stm32f7xx_nucleo_144.c stm32f7xx_nucleo_144.h
  group Hardware_Device_Driver/Microcontroller_Driver
    ../Measurement_System/Hardware_Device_Driver/Microcontroller_Driver/: I_NVIC_Dispatcher_Config.h I_NVIC_Dispatcher_Types.h ICB_ServiceInterrupt.h
  group Hardware_Device_Driver/Microcontroller_Driver/STM32F7xx/HAL_Driver
    ../Measurement_System/Hardware_Device_Driver/Microcontroller_Driver/STM32F7xx/HAL_Driver/Src/: stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c
  group Hardware_Device_Driver/Microcontroller_Driver/STM32F7xx/NVIC_Dispatcher
    ../Measurement_System/Hardware_Device_Driver/Microcontroller_Driver/STM32F7xx/NVIC_Dispatcher/: STM32F7xx_NVIC_Dispatcher.c STM32F7xx_NVIC_Dispatcher.h
  group Hardware_Device_Driver/Microcontroller_Configuration/STM32F7xx
    ../Measurement_System/Hardware_Device_Driver/Microcontroller_Configuration/STM32F7xx/: stm32f7xx_hal_conf.h stm32f7xx_hal_msp.c stm32f7xx_it.c stm32f7xx_it.h system_stm32f7xx.c stm32f7xx_setup.c stm32f7xx_setup.h
  group Hardware_Device_Driver/Microcontroller_Configuration/STM32F7xx/MDK-ARM
    ../Measurement_System/Hardware_Device_Driver/Microcontroller_Configuration/STM32F7xx/MDK-ARM/: startup_stm32f746xx.s Typedefs.h
  group Library/State_Machine
    ../Measurement_System/Library/State_Machine/: State.h State.c StateMachine.h StateMachine.c StateMachineGlobals.h
software components: CMSIS:CORE 5.3.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0

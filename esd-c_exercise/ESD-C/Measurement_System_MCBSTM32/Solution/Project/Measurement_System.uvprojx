# Keil uVision project Measurement_System.uvprojx, settings and files
target MCBSTM32_Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Measurement_System
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Measurement_System\Hardware_Device_Abstraction\AnalogMeasurement;..\Measurement_System\Hardware_Device_Abstraction\ComSerial;..\Measurement_System\Hardware_Device_Abstraction\UserIndication;..\Measurement_System\Hardware_Device_Abstraction\UserInput;..\Measurement_System\Hardware_Device_Abstraction\UserOutput;..\Measurement_System\Hardware_Device_Driver\Board_Driver\MCBSTM32\Button_MCBSTM32;..\Measurement_System\Hardware_Device_Driver\Board_Driver\MCBSTM32\LCD_Text_MCBSTM32;..\Measurement_System\Hardware_Device_Driver\Board_Driver\MCBSTM32\LED_MCBSTM32;..\Measurement_System\Library\State_Machine;..\Measurement_System\Hardware_Device_Driver\Microcontroller_Driver\STM32F103\ADC_STM32F103;..\Measurement_System\Hardware_Device_Driver\Microcontroller_Driver\STM32F103\GPIO_STM32F103;..\Measurement_System\Hardware_Device_Driver\Microcontroller_Driver\STM32F103\NVIC_Dispatcher_STM32F103;..\Measurement_System\Hardware_Device_Driver\Microcontroller_Driver\STM32F103\NVIC_STM32F103;..\Measurement_System\Measurement_Application\Measurement_Controller;..\Measurement_System\Measurement_Application\Measurement;..\Measurement_System\System_Management;..\Measurement_System\Hardware_Device_Abstraction;..\Measurement_System\Hardware_Device_Driver;..\Measurement_System\Hardware_Device_Driver\Microcontroller_Driver;..\Measurement_System\Hardware_Device_Driver\Board_Driver;..\Measurement_System\Measurement_Application;..\Measurement_System\Hardware_Device_Driver\Microcontroller_Driver\STM32F103;..\Measurement_System\Hardware_Device_Driver\Microcontroller_Driver\STM32F103\USART_STM32F103
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System_Management
    ../Measurement_System/System_Management/: Measurement_Application_main.c SystemManager.h SystemManager.c
  group Measurement_Application
    ../Measurement_System/Measurement_Application/: ApplicationManager.h ApplicationManager.c
  group Measurement_Application/Measurement_Controller
    ../Measurement_System/Measurement_Application/Measurement_Controller/: MeasurementController.c MeasurementController.h MeasurementController_Events.h
  group Measurement_Application/Measurement
    ../Measurement_System/Measurement_Application/Measurement/: Measurement.h Measurement.c VoltageMeasurement.h VoltageMeasurement.c CurrentMeasurement.h CurrentMeasurement.c ResistanceMeasurement.h ResistanceMeasurement.c
  group Hardware_Device_Abstraction
    ../Measurement_System/Hardware_Device_Abstraction/: DeviceAbstractionManager.h DeviceAbstractionManager.c
  group Hardware_Device_Abstraction/ComSerial
    ../Measurement_System/Hardware_Device_Abstraction/ComSerial/: I_ComSerial.h I_ComSerial_Config.h ICB_ComSerial.h ComSerial.h ComSerial.c
  group Hardware_Device_Abstraction/AnalogMeasurement
    ../Measurement_System/Hardware_Device_Abstraction/AnalogMeasurement/: I_AnalogMeasurement.h I_AnalogMeasurement_Config.h ICB_AnalogMeasurement.h AnalogMeasurement.h AnalogMeasurement.c
  group Hardware_Device_Abstraction/UserIndication
    ../Measurement_System/Hardware_Device_Abstraction/UserIndication/: I_UserIndication.h I_UserIndication_Config.h UserIndication.h UserIndication.c
  group Hardware_Device_Abstraction/UserInput
    ../Measurement_System/Hardware_Device_Abstraction/UserInput/: I_UserInput.h I_UserInput_Config.h UserInput.h UserInput.c
  group Hardware_Device_Abstraction/UserOutput
    ../Measurement_System/Hardware_Device_Abstraction/UserOutput/: I_UserOutput.h I_UserOutput_Config.h UserOutput.h UserOutput.c
  group Hardware_Device_Driver
    ../Measurement_System/Hardware_Device_Driver/: DriverManager.h DriverManager.c
  group Hardware_Device_Driver/Microcontroller_Driver
    ../Measurement_System/Hardware_Device_Driver/Microcontroller_Driver/: I_GPIO.h I_GPIO_Config.h I_GPIO_Types.h I_USART.h I_USART_Config.h I_ADC.h I_ADC_Config.h I_NVIC.h I_NVIC_Config.h I_NVIC_Dispatcher_Config.h I_NVIC_Dispatcher_Types.h ICB_ServiceInterrupt.h Typedefs.h
  group Hardware_Device_Driver/Microcontroller_Driver/STM32F103
    ../Measurement_System/Hardware_Device_Driver/Microcontroller_Driver/STM32F103/: RegisterMap_STM32F103.h
  group Hardware_Device_Driver/Microcontroller_Driver/STM32F103/GPIO_STM32F103
    ../Measurement_System/Hardware_Device_Driver/Microcontroller_Driver/STM32F103/GPIO_STM32F103/: GPIO_Driver_STM32F103.h GPIO_Driver_STM32F103.c GPIO_Register_STM32F103.h GPIO_Register_STM32F103.c
  group Hardware_Device_Driver/Microcontroller_Driver/STM32F103/ADC_STM32F103
    ../Measurement_System/Hardware_Device_Driver/Microcontroller_Driver/STM32F103/ADC_STM32F103/: ADC_Driver_STM32F103.h ADC_Driver_STM32F103.c ADC_Register_STM32F103.h ADC_Register_STM32F103.c
  group Hardware_Device_Driver/Microcontroller_Driver/STM32F103/USART_STM32F103
    ../Measurement_System/Hardware_Device_Driver/Microcontroller_Driver/STM32F103/USART_STM32F103/: USART_STM32F103.h USART_STM32F103.c USART_Driver_STM32F103.h USART_Driver_STM32F103.c USART_Register_STM32F103.h USART_Register_STM32F103.c
  group Hardware_Device_Driver/Microcontroller_Driver/STM32F103/NVIC_STM32F103
    ../Measurement_System/Hardware_Device_Driver/Microcontroller_Driver/STM32F103/NVIC_STM32F103/: NVIC_Driver_STM32F103.h NVIC_Driver_STM32F103.c NVIC_Register_STM32F103.h NVIC_Register_STM32F103.c
  group Hardware_Device_Driver/Microcontroller_Driver/STM32F103/NVIC_Dispatcher_STM32F103
    ../Measurement_System/Hardware_Device_Driver/Microcontroller_Driver/STM32F103/NVIC_Dispatcher_STM32F103/: NVIC_Dispatcher_STM32F103.h NVIC_Dispatcher_STM32F103.c ICB_AcknowledgeInterrupt.h
  group Hardware_Device_Driver/Board_Driver
    ../Measurement_System/Hardware_Device_Driver/Board_Driver/: I_Button.h I_Button_Config.h I_Button_Types.h I_LED.h I_LED_Config.h I_LCD_Text.h I_LCD_Text_Config.h
  group Hardware_Device_Driver/Board_Driver/MCBSTM32/Button_MCBSTM32
    ../Measurement_System/Hardware_Device_Driver/Board_Driver/MCBSTM32/Button_MCBSTM32/: Button_MCBSTM32.h Button_MCBSTM32.c
  group Hardware_Device_Driver/Board_Driver/MCBSTM32/LED_MCBSTM32
    ../Measurement_System/Hardware_Device_Driver/Board_Driver/MCBSTM32/LED_MCBSTM32/: LED_MCBSTM32.h LED_MCBSTM32.c
  group Hardware_Device_Driver/Board_Driver/MCBSTM32/LCD_Text_MCBSTM32
    ../Measurement_System/Hardware_Device_Driver/Board_Driver/MCBSTM32/LCD_Text_MCBSTM32/: LCD_Text_AC162D_KS0066U.h LCD_Text_AC162D_KS0066U.c
  group Library/State_Machine
    ../Measurement_System/Library/State_Machine/: State.h State.c StateMachine.h StateMachine.c StateMachineGlobals.h
software components: CMSIS:CORE 5.3.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0

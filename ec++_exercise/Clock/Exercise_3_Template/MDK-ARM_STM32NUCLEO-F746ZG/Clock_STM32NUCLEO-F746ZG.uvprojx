# Keil uVision project Clock_STM32NUCLEO-F746ZG.uvprojx, settings and files
target STM32NUCLEO-F746ZG (6180000::V6.18::ARMCLANG)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.1
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F746ZG_Nucleo
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32F7XX_NUCLEO_144
  c include: ..\Source\Platform\Hardware_Abstraction\Device_Driver_Abstraction\STM32F7xx\CMSIS\Device\ST\STM32F7xx\Include;..\Source\Platform\Hardware_Abstraction\Device_Driver_Abstraction\STM32F7xx\STM32F7xx_HAL_Driver\Inc;..\Source\Platform\Hardware_Abstraction\Board_Driver_Abstraction\BSP_STM32F7xx_Nucleo_144;..\Source\Platform\Build_Environment\MDK-ARM_STM32F7xx;..\Source\Hardware_Configuration\MDK-ARM\STM32F7xx;..\Source\Clock_Application_Builder_Main\STM32NUCLEO-F746ZG
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Clock_Application_Builder_Main
    ../Source/Clock_Application_Builder_Main/: mClockApplicationMain.hpp mClockApplicationMain.cpp
    ../Source/Clock_Application_Builder_Main/STM32NUCLEO-F746ZG/: cClockApplicationBuilder.hpp cClockApplicationBuilder.cpp
  group Clock_Application
    ../Source/Clock_Application/: cClockApplication.hpp cClockApplication.cpp
  group Clock
    ../Source/Clock/: icClock.hpp icbcAlarmClock.hpp cClock.hpp cClock.cpp cAlarmClock.hpp cAlarmClock.cpp cAlarmTime.hpp cAlarmTime.cpp
  group Counter
    ../Source/Counter/: cLimitCounter.hpp cLimitCounter.cpp cOverflowCounter.hpp cOverflowCounter.cpp
  group Platform/Build_Environment
    ../Source/Platform/Build_Environment/MDK-ARM_STM32F7xx/: TypeDefinitions.hpp
  group Platform/Hardware_Abstraction
    ../Source/Platform/Hardware_Abstraction/: imBasicIO.hpp
  group Platform/Hardware_Abstraction/Device_Driver_Abstraction
    ../Source/Platform/Hardware_Abstraction/Device_Driver_Abstraction/: icbcInterruptAcknowledge.hpp icbcInterruptDispatcher.hpp icTimer.hpp
  group Platform/Hardware_Abstraction/Device_Driver_Abstraction/STM32F7xx/BasicIO
    ../Source/Platform/Hardware_Abstraction/Device_Driver_Abstraction/STM32F7xx/BasicIO/: mBasicIO_iostream.cpp mBasicIO_stdio.cpp
  group Platform/Hardware_Abstraction/Device_Driver_Abstraction/STM32F7xx/TIMER
    ../Source/Platform/Hardware_Abstraction/Device_Driver_Abstraction/STM32F7xx/TIMER/: cSTM32F7xxTIMER_Register.hpp cSTM32F7xxTIMER_Register.cpp cSTM32F7xxTIMER_Driver.hpp cSTM32F7xxTIMER_Driver.cpp
  group Platform/Hardware_Abstraction/Device_Driver_Abstraction/STM32F7xx/NVIC_Dispatcher
    ../Source/Platform/Hardware_Abstraction/Device_Driver_Abstraction/STM32F7xx/NVIC_Dispatcher/: cSTM32F7xxNVIC_Register.hpp cSTM32F7xxNVIC_Register.cpp cSTM32F7xxNVIC_Driver.hpp cSTM32F7xxNVIC_Driver.cpp cSTM32F7xxNVIC_Dispatcher.hpp cSTM32F7xxNVIC_Dispatcher.cpp mSTM32F7xxNVIC_Wrapper.cpp mSTM32F7xxNVIC_Types.hpp
  group Platform/Hardware_Abstraction/Device_Driver_Abstraction/STM32F7xx/STM32F7xx_HAL_Driver
    ../Source/Platform/Hardware_Abstraction/Device_Driver_Abstraction/STM32F7xx/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c
  group Platform/Hardware_Abstraction/Board_Driver_Abstraction/BSP_STM32F7xx_Nucleo_144
    ../Source/Platform/Hardware_Abstraction/Board_Driver_Abstraction/BSP_STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c stm32f7xx_nucleo_144.h
  group Hardware_Configuration/MDK-ARM/STM32F7xx
    ../Source/Hardware_Configuration/MDK-ARM/STM32F7xx/: mHardwareConfiguration.h mHardwareConfiguration.c stm32f7xx_hal_msp.c stm32f7xx_it.c system_stm32f7xx.c
  group Hardware_Configuration/MDK-ARM/STM32F7xx/Startup
    ../Source/Hardware_Configuration/MDK-ARM//STM32F7xx/Startup/: startup_stm32f746xx.s
software components: CMSIS:CORE 5.3.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0

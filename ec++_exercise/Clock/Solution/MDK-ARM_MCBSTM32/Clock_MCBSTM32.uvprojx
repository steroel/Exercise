# Keil uVision project Clock_MCBSTM32.uvprojx, settings and files
target MCBSTM32 (6160000::V6.16::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: Clock
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: USE_HAL_DRIVER,STM32F103xB, RTE_Compiler_IO_STDOUT_User, RTE_Compiler_IO_STDIN_User, TARGET=1
  c misc: -fno-exceptions -fno-rtti
  c include: ..\Source\Platform\Hardware_Abstraction\Device_Driver_Abstraction\STM32F1xx\CMSIS\Device\ST\STM32F1xx\Include;..\Source\Platform\Hardware_Abstraction\Device_Driver_Abstraction\STM32F1xx\STM32F1xx_HAL_Driver\Inc;..\Source\Platform\Hardware_Abstraction\Board_Driver_Abstraction\BSP_MCBSTM32;..\Source\Platform\Build_Environment\MDK-ARM_STM32F1xx;..\Source\Hardware_Configuration\MDK-ARM\STM32F1xx;..\Source\Clock_Application_Builder_Main\MCBSTM32
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Clock_Application_Builder_Main
    ../Source/Clock_Application_Builder_Main/: mClockApplicationMain.hpp mClockApplicationMain.cpp
    ../Source/Clock_Application_Builder_Main/MCBSTM32/: cClockApplicationBuilder.hpp cClockApplicationBuilder.cpp
  group Clock_Application
    ../Source/Clock_Application/: cClockApplication.hpp cClockApplication.cpp
  group Clock
    ../Source/Clock/: icClock.hpp icbcAlarmClock.hpp cClock.hpp cClock.cpp cAlarmClock.hpp cAlarmClock.cpp cAlarmTime.hpp cAlarmTime.cpp
  group Counter
    ../Source/Counter/: cLimitCounter.hpp cLimitCounter.cpp cOverflowCounter.hpp cOverflowCounter.cpp
  group Platform/Build_Environment
    ../Source/Platform/Build_Environment/MDK-ARM_STM32F1xx/: TypeDefinitions.hpp
  group Platform/Hardware_Abstraction
    ../Source/Platform/Hardware_Abstraction/: imBasicIO.hpp
  group Platform/Hardware_Abstraction/Device_Driver_Abstraction
    ../Source/Platform/Hardware_Abstraction/Device_Driver_Abstraction/: icbcInterruptAcknowledge.hpp icbcInterruptDispatcher.hpp icTimer.hpp
  group Platfrom/Hardware_Abstraction/Device_Driver_Abstraction/STM32F1xx/BasicIO
    ../Source/Platform/Hardware_Abstraction/Device_Driver_Abstraction/STM32F1xx/BasicIO/: mBasicIO_iostream.cpp mBasicIO_stdio.cpp
  group Patform/Hardware_Abstraction/Device_Driver_Abstraction/STM32F1xx/TIMER
    ../Source/Platform/Hardware_Abstraction/Device_Driver_Abstraction/STM32F1xx/TIMER/: cSTM32F1xxTIMER_Register.hpp cSTM32F1xxTIMER_Register.cpp cSTM32F1xxTIMER_Driver.hpp cSTM32F1xxTIMER_Driver.cpp
  group Patform/Hardware_Abstraction/Device_Driver_Abstraction/STM32F1xx/NVIC_Dispatcher
    ../Source/Platform/Hardware_Abstraction/Device_Driver_Abstraction/STM32F1xx/NVIC_Dispatcher/: cSTM32F1xxNVIC_Register.hpp cSTM32F1xxNVIC_Register.cpp cSTM32F1xxNVIC_Driver.hpp cSTM32F1xxNVIC_Driver.cpp cSTM32F1xxNVIC_Dispatcher.hpp cSTM32F1xxNVIC_Dispatcher.cpp mSTM32F1xxNVIC_Wrapper.cpp mSTM32F1xxNVIC_Types.hpp
  group Patform/Hardware_Abstraction/Device_Driver_Abstraction/STM32F1xx/STM32F1xx_HAL_Driver
    ../Source/Platform/Hardware_Abstraction/Device_Driver_Abstraction/STM32F1xx/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Patform/Hardware_Abstraction/Board_Driver_Abstraction/BSP_MCBSTM32
    ../Source/Platform/Hardware_Abstraction/Board_Driver_Abstraction/BSP_MCBSTM32/: mMCBSTM32_LED.c mMCBSTM32_LED.h
  group Hardware_Configuration/MDK-ARM/STM32F1xx
    ../Source/Hardware_Configuration/MDK-ARM/STM32F1xx/: mHardwareConfiguration.h mHardwareConfiguration.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
  group Hardware_Configutation/MDK-ARM/STM32F10x/Startup
    ../Source/Hardware_Configuration/MDK-ARM/STM32F1xx/Startup/: startup_stm32f103xb.s
target Simulator (6180000::V6.18::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Clock
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB, RTE_Compiler_IO_STDOUT_User, RTE_Compiler_IO_STDIN_User, TARGET=0
  c misc: -fno-exceptions -fno-rtti
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.5.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
